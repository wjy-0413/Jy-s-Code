# Keil uVision project Interrupt Test.uvproj, settings and files
target STC89C52 (MCS-51)
  device: AT89S51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(33000000) MODAT2
  output: Interrupt Test +hex
  c flags: Optimize=8 SizeSpeed=1
  group Main
    ./: STARTUP.A51 main.c
